# IAR project GSM_RTSO_FATFS.ewp, settings and files
configuration GSM_RTSO_FATFS (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; STM32F407XX
  ICCARM.CCIncludePath2: ../Inc; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ..\GSM; ../Drivers/STM32F4xx_HAL_Driver/Inc; ..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\Drivers\SPL\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: GSM_RTSO_FATFS.srec
  ILINK.IlinkOutputFile: GSM_RTSO_FATFS.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
  group Application/User
    ../Src/: freertos.c gpio.c iwdg.c main.c spi.c stm32f4xx_hal_msp.c stm32f4xx_it.c tim.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
    ../GSM/: hardwareProfile.h
  group Application/User/GSM
    ../GSM/: 1Wire.c 1Wire.h Arch.c Arch.h ComPort.c ComPort.h GenericTypeDefs.h gsm.c gsm.h programming.c programming.h SMS.c SMS.h SPI_Flash.c TcpIp.c TcpIp.h tick.h TQueue.c TQueue.h VoiceCall.c VoiceCall.h
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/SPL
    ../Drivers/SPL/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
    ../Drivers/SPL/inc/: misc.h stm32f4xx_gpio.h stm32f4xx_rcc.h stm32f4xx_usart.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_usb.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
